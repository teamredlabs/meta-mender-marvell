require recipes-bsp/u-boot/u-boot-mender.inc
require u-boot-common-marvell.inc
